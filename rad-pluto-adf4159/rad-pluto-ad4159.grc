options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LO
  id: variable_qtgui_range
  parameters:
    label: LO Frequency
    rangeType: int
    start: '2400000000'
    step: '1000'
    stop: '2500000000'
    value: '2400000000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    rangeType: int
    start: '6000000000'
    step: '1000'
    stop: '7000000000'
    value: '6000000000'
  states: {}
- name: frequency_deviation_range
  id: variable_qtgui_range
  parameters:
    label: Frequency Deviation Range
    rangeType: int
    start: '0'
    step: '1000'
    stop: '100000000'
    value: '10000000'
  states: {}
- name: frequency_deviation_step
  id: variable_qtgui_range
  parameters:
    label: Frequency Deviation Step
    rangeType: int
    start: '0'
    step: '10'
    stop: '1000000'
    value: '1000'
  states: {}
- name: frequency_deviation_time
  id: variable_qtgui_range
  parameters:
    label: Frequency Deviation Time
    rangeType: int
    start: '0'
    step: '1000'
    stop: '10000000'
    value: '10000'
  states: {}
- name: powerdown
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: Powerdown
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: ramp_mode
  id: variable_qtgui_chooser
  parameters:
    label: Ramp Mode
    label0: '"disabled"'
    label1: '"continuous_sawtooth"'
    label2: '"continuous_triangular"'
    label3: '"single_sawtooth_burst"'
    label4: '"single_ramp_burst"'
    num_opts: '5'
    option0: '"disabled"'
    option1: '"continuous_sawtooth"'
    option2: '"continuous_triangular"'
    option3: '"single_sawtooth_burst"'
    option4: '"single_ramp_burst"'
    type: string
    value: '"disabled"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000000'
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: fft_size
    vlen_out: '1'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: '"frequency"'
    target: int(frequency)
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: '"ramp_mode"'
    target: ramp_mode
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: '"powerdown"'
    target: powerdown
  states: {}
- name: blocks_var_to_msg_0_0_1
  id: blocks_var_to_msg
  parameters:
    msgname: '"frequency_deviation_step"'
    target: frequency_deviation_step
  states: {}
- name: blocks_var_to_msg_0_0_2
  id: blocks_var_to_msg
  parameters:
    msgname: '"frequency_deviation_range"'
    target: 'frequency_deviation_range '
  states: {}
- name: blocks_var_to_msg_0_0_2_0
  id: blocks_var_to_msg
  parameters:
    msgname: '"frequency_deviation_time"'
    target: frequency_deviation_time
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr 
      import pmt

      class msg_block(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="msg_to_iio_block",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
          def handle_msg(self, msg):
              nkey0 = pmt.intern(str(pmt.car(msg)))
              nval0 = pmt.intern(str(pmt.cdr(msg)))
              msg_dic = pmt.make_dict()
              msg_dic = pmt.dict_add(msg_dic, nkey0, nval0)
              self.message_port_pub(pmt.intern('msg_out'), msg_dic)
    alias: msg_to_iio_dict
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage0
    device: adf4159
    output: 'True'
    uri: ip:analog.local
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {state: disabled}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: LO
    gain1: '''manual'''
    manual_gain1: '0'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1.0'
    fft_size: fft_size
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: LO
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '-10'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [blocks_max_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_var_to_msg_0, msgout, epy_block_0, msg_in]
- [blocks_var_to_msg_0_0, msgout, epy_block_0, msg_in]
- [blocks_var_to_msg_0_0_0, msgout, epy_block_0, msg_in]
- [blocks_var_to_msg_0_0_1, msgout, epy_block_0, msg_in]
- [blocks_var_to_msg_0_0_2, msgout, epy_block_0, msg_in]
- [blocks_var_to_msg_0_0_2_0, msgout, epy_block_0, msg_in]
- [epy_block_0, msg_out, blocks_message_debug_1, print]
- [epy_block_0, msg_out, iio_attr_sink_0, attr]
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [iio_pluto_source_1, '0', logpwrfft_x_0, '0']
- [iio_pluto_source_1, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [logpwrfft_x_0, '0', blocks_max_xx_0, '0']

metadata:
  file_format: 1
